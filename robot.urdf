Commit message: fat bois

File: robot.urdf (robot description, URDF)
Before this commit: robot robot, 1 links, 0 joints
Links:
- link base_link: geometry collision cylinder length=0.5 radius=0.45; visual cylinder length=0.5 radius=0.45
